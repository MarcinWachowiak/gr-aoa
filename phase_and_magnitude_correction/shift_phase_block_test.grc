options:
  parameters:
    generate_options: qt_gui
    id: run_shift_phase_block_test
    output_language: python
    title: Shift phase block test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '3.14'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase
  parameters:
    dummy_param: ''
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', aoa_shift_phase_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [aoa_shift_phase_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', aoa_shift_phase_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
