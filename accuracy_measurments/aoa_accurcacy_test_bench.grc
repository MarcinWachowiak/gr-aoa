options:
  parameters:
    comment: |-
      Wait for the phase shift coefficient to stabilise - 5min
      "num_recv_frames=1024" is absolutely critical for consistent data flow


      To properly trigger filename changes
      grc flowgraph genrated py code needs to be edited.

      Place file_sink open callback  line in set_trigger_measurment: 

      def set_trigger_measurment(self, trigger_measurment):
              self.trigger_measurment = trigger_measurment
              self._trigger_measurment_callback(self.trigger_measurment)

              if trigger_measurment == True:
                  self.blocks_file_sink_0.open(testbench_setup_pymodule.get_meas_path("aoa",self.distance, self.rx_gain, self.src_att, self.physical_aoa))
                  self.blocks_file_sink_0_0.open(testbench_setup_pymodule.get_meas_path("ch1",self.distance, self.rx_gain, self.src_att, self.physical_aoa))
                  self.blocks_file_sink_0_0_0.open(testbench_setup_pymodule.get_meas_path("ch2",self.distance, self.rx_gain, self.src_att, self.physical_aoa))

                  self.aoa_head_w_rst_0.reset(True)
                  self.aoa_head_w_rst_0_0.reset(True)
                  self.aoa_head_w_rst_0_0_0.reset(True)

                  self.blocks_selector_1.set_output_index(self.trigger_measurment)
                  self.blocks_selector_1_0.set_output_index(self.trigger_measurment)
                  self.blocks_selector_1_0_0.set_output_index(self.trigger_measurment)
    generate_options: qt_gui
    id: run_aoa_accucracy_test_bench
    output_language: python
    title: AoA estimation accuracy test bench
  states: {}

blocks:
- name: calibrate_phase_offsets
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab_1@0:0,0,1,1
    label: Calibrate phase offsets?
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: int(2.4399e+9)
  states: {}
- name: distance
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_3@0:2,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '10'
    value: '2'
  states: {}
- name: master_freq
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: mav_length
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: n_raw_samples
  id: variable
  parameters:
    value: 60*samp_rate
  states: {}
- name: n_saved_sampl
  id: variable
  parameters:
    value: int(samp_rate/(snap_size-overlap_size)*60)
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: physical_aoa
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_3@0:3,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '90'
  states: {}
- name: pluto_samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: pluto_tx_active
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab_1@0:1,0,1,1
    label: PLUTO TX active
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_3@0:0,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: snap_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: src_att
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_3@0:1,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: trigger_measurment
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: tab_1@0:2,0,1,1
    label: Trigger measurment
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: calibrate_phase_offsets
    type: byte
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '115e+3'
    offset: '0'
    phase: '0'
    samp_rate: pluto_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: overlap_size
    snapshot_size: snap_size
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '1'
    norm_spacing: '0.5'
  states: {}
- name: aoa_head_w_rst_0
  id: aoa_head_w_rst
  parameters:
    dump_buff: 'True'
    num_items: n_saved_sampl
    type: float
    vlen: '1'
  states: {}
- name: aoa_head_w_rst_0_0
  id: aoa_head_w_rst
  parameters:
    dump_buff: 'True'
    num_items: n_raw_samples
    type: complex
    vlen: '1'
  states: {}
- name: aoa_head_w_rst_0_0_0
  id: aoa_head_w_rst
  parameters:
    dump_buff: 'True'
    num_items: n_raw_samples
    type: complex
    vlen: '1'
  states: {}
- name: aoa_precise_moving_average_0
  id: aoa_precise_moving_average
  parameters:
    length: mav_length
    max_iter: mav_length
  states: {}
- name: aoa_rootMUSIC_linear_array_0
  id: aoa_rootMUSIC_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase
  parameters:
    dummy_param: ''
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-physical_aoa'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/aoa_err.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/ch_1_raw.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/ch_2_raw.bin
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: pluto_tx_active
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: trigger_measurment
    type: float
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: trigger_measurment
    type: complex
  states: {}
- name: blocks_selector_1_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: trigger_measurment
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: src_att
    auto_filter: 'True'
    bandwidth: pluto_samp_rate
    buffer_size: 2**18
    cyclic: 'False'
    frequency: center_frequency
    samplerate: pluto_samp_rate
    uri: 192.168.0.40
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tab_2@0:2,0,1,1
    is_pair: 'False'
    is_static: 'False'
    label: AoA error measurment status
    type: string
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tab_2@0:3,0,1,1
    is_pair: 'False'
    is_static: 'False'
    label: CH1 measurment status
    type: string
  states: {}
- name: qtgui_edit_box_msg_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tab_2@0:4,0,1,1
    is_pair: 'False'
    is_static: 'False'
    label: CH2 measurment status
    type: string
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_2@0:0,0,1,1
    max: '2'
    min: '-2'
    name: '"Arg corrector coeff"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_2@0:1,0,1,1
    max: '180'
    min: '0'
    name: '"Estimated AoA"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    entags: 'False'
    grid: 'True'
    gui_hint: tab_4@0:1,0,1,1
    name: '"Signals before phase correction (unfiltered)"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '-0.3'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    color2: green
    entags: 'False'
    grid: 'True'
    gui_hint: tab_4@0:1,1,1,1
    name: '"Signals after phase correction"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '-0.3'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tab_4@0:0,1,1,1
    label1: AoA error
    name: '"AoA error"'
    size: int(10e3)
    srate: samp_rate/(snap_size-overlap_size)
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    gui_hint: tab_4@0:0,0,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: tab_1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Controls
    num_tabs: '1'
  states: {}
- name: tab_2
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,1,1
    label0: Indicators
    num_tabs: '1'
  states: {}
- name: tab_3
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,2,1,1
    label0: Parameters
    num_tabs: '1'
  states: {}
- name: tab_4
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,3
    label0: Plots
    num_tabs: '1'
  states: {}
- name: test_bench_setup_pymodule
  id: epy_module
  parameters:
    source_code: "import os \nfrom os import path\n\ndef get_meas_path(file_type, distance, rx_gain, src_att, physical_aoa):\n    glob_path = os.getcwd()\n    meas_dir = \"%s/meas_dist_%dm_rx_%ddB_src_att_%ddB\" %(glob_path, distance, rx_gain, src_att)\n\n    try:\n        os.mkdir(meas_dir)\n    except OSError:\n        if(path.exists(meas_dir)):\n            print (\"Directory: %s already exists, skipping\" % meas_dir)\n        else:\n            print (\"Creation of the directory: %s failed\" % meas_dir)\n    else:\n        print (\"Successfully created the directory: %s \" % meas_dir)\n\n    meas_path = \"\"\n    if(file_type == \"aoa\"):\n        meas_path = \"%s/angle_%d_err.bin\" %(meas_dir,physical_aoa)\n    elif(file_type == \"ch1\"):\n        meas_path = \"%s/raw_ch_1_%d.bin\" %(meas_dir,physical_aoa)\n    elif(file_type == \"ch2\"):\n        meas_path = \"%s/raw_ch_2_%d.bin\" %(meas_dir,physical_aoa)\n    else:\n        print(\"Unknown file type %s!\" %file_type)\n\n    print(meas_path)\n    return meas_path\n\n\n\n\n\n"
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_frequency
    center_freq1: center_frequency
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '"num_recv_frames=1024, master_clock_rate= %f" % master_freq'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sample_and_hold_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_selector_0_0, '1']
- [aoa_autocorrelate_0, '0', aoa_rootMUSIC_linear_array_0, '0']
- [aoa_calc_phase_diff_0, '0', aoa_precise_moving_average_0, '0']
- [aoa_head_w_rst_0, '0', blocks_add_const_vxx_0, '0']
- [aoa_head_w_rst_0, status, qtgui_edit_box_msg_0, val]
- [aoa_head_w_rst_0_0, '0', blocks_file_sink_0_0, '0']
- [aoa_head_w_rst_0_0, status, qtgui_edit_box_msg_0_0, val]
- [aoa_head_w_rst_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [aoa_head_w_rst_0_0_0, status, qtgui_edit_box_msg_0_0_0, val]
- [aoa_precise_moving_average_0, '0', blocks_sample_and_hold_xx_0, '0']
- [aoa_rootMUSIC_linear_array_0, '0', blocks_selector_1, '0']
- [aoa_rootMUSIC_linear_array_0, '0', qtgui_number_sink_0_0, '0']
- [aoa_shift_phase_0, '0', aoa_autocorrelate_0, '1']
- [aoa_shift_phase_0, '0', blocks_complex_to_real_0_2, '0']
- [band_pass_filter_0_0_0_0, '0', aoa_autocorrelate_0, '0']
- [band_pass_filter_0_0_0_0, '0', aoa_calc_phase_diff_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', aoa_calc_phase_diff_0, '1']
- [band_pass_filter_0_0_0_0_0, '0', aoa_shift_phase_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [band_pass_filter_0_0_0_0_0, '0', blocks_complex_to_real_0_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', qtgui_waterfall_sink_x_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_real_0_2, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_divide_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_null_source_0_0, '0', blocks_selector_0_0, '0']
- [blocks_sample_and_hold_xx_0, '0', aoa_shift_phase_0, '1']
- [blocks_sample_and_hold_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_0, '0']
- [blocks_selector_1, '1', aoa_head_w_rst_0, '0']
- [blocks_selector_1_0, '0', blocks_null_sink_0_0, '0']
- [blocks_selector_1_0, '1', aoa_head_w_rst_0_0, '0']
- [blocks_selector_1_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_selector_1_0_0, '1', aoa_head_w_rst_0_0_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_1_0, '0']
- [uhd_usrp_source_0, '1', band_pass_filter_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_selector_1_0_0, '0']

metadata:
  file_format: 1
