options:
  parameters:
    generate_options: no_gui
    id: run_noise_pow_meas
    output_language: python
    run_options: run
    title: Noise power level measument
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: int(2.4399e+9)
  states: {}
- name: master_freq
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: n_saved_sampl
  id: variable
  parameters:
    value: int(10000*180)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: aoa_filename
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: aoa_precise_moving_average_0
  id: aoa_precise_moving_average
  parameters:
    length: int(1e6)
    max_iter: int(1e6)
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: snr_filename
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: n_saved_sampl
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: float(1e6)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e6)
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e6)
    type: complex
  states: {}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: int(1e6)
    type: float
  states: {}
- name: fir_filter_xxx_0_2_1
  id: fir_filter_xxx
  parameters:
    decim: '100'
    taps: '1'
    type: fff
  states: {}
- name: phase_coeff
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: snr_filename
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: src_att
  id: parameter
  parameters:
    type: intx
    value: '30'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_frequency
    center_freq1: center_frequency
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '"num_recv_frames=1024, master_clock_rate= %f" % master_freq'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [aoa_precise_moving_average_0, '0', blocks_skiphead_1, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', aoa_precise_moving_average_0, '0']
- [blocks_skiphead_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_skiphead_0_0, '0', band_pass_filter_0_0_0_0_0, '0']
- [blocks_skiphead_1, '0', fir_filter_xxx_0_2_1, '0']
- [fir_filter_xxx_0_2_1, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']
- [uhd_usrp_source_0, '1', blocks_skiphead_0_0, '0']

metadata:
  file_format: 1
