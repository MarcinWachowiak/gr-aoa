options:
  parameters:
    generate_options: no_gui
    id: run_music_algo_from_file
    output_language: python
    run_options: run
    title: Music algorithm from file
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: phase_coeff
    type: float
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: '2'
    overlap_size: overlap_size
    snapshot_size: snap_size
  states: {}
- name: aoa_rootMUSIC_linear_array_0
  id: aoa_rootMUSIC_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase
  parameters:
    dummy_param: ''
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-physical_aoa'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file_path_1
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file_path_1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: in_file_path_2
    repeat: 'False'
    type: complex
  states: {}
- name: in_file_path_1
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: in_file_path_2
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: out_file_path_1
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: overlap_size
  id: parameter
  parameters:
    type: intx
    value: '1024'
  states: {}
- name: phase_coeff
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: physical_aoa
  id: parameter
  parameters:
    type: eng_float
    value: '90'
  states: {}
- name: snap_size
  id: parameter
  parameters:
    type: intx
    value: '2048'
  states: {}

connections:
- [analog_const_source_x_0, '0', aoa_shift_phase_0, '1']
- [aoa_autocorrelate_0, '0', aoa_rootMUSIC_linear_array_0, '0']
- [aoa_rootMUSIC_linear_array_0, '0', blocks_add_const_vxx_0, '0']
- [aoa_shift_phase_0, '0', aoa_autocorrelate_0, '1']
- [band_pass_filter_0_0_0_0, '0', aoa_autocorrelate_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', aoa_shift_phase_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_file_source_0_0, '0', band_pass_filter_0_0_0_0_0, '0']

metadata:
  file_format: 1
