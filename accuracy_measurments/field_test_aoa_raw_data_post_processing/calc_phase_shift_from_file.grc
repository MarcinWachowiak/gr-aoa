options:
  parameters:
    generate_options: no_gui
    id: run_calc_phase_shift_from_file
    output_language: python
    run_options: run
    title: Calculate phase shift from file
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '1'
    norm_spacing: '0.5'
  states: {}
- name: aoa_precise_moving_average_0
  id: aoa_precise_moving_average
  parameters:
    length: mav_length
    max_iter: mav_length
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file_path
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file_path_1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: in_file_path_2
    repeat: 'False'
    type: complex
  states: {}
- name: in_file_path_1
  id: parameter
  parameters:
    label: in_file_path_1
    type: str
    value: ''
  states: {}
- name: in_file_path_2
  id: parameter
  parameters:
    label: in_file_path_2
    type: str
    value: ''
  states: {}
- name: mav_length
  id: parameter
  parameters:
    label: mav_length
    type: intx
    value: int(1e5)
  states: {}
- name: out_file_path
  id: parameter
  parameters:
    label: out_file_path
    type: str
    value: ''
  states: {}

connections:
- [aoa_calc_phase_diff_0, '0', aoa_precise_moving_average_0, '0']
- [aoa_precise_moving_average_0, '0', blocks_file_sink_0, '0']
- [band_pass_filter_0_0_0_0, '0', aoa_calc_phase_diff_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', aoa_calc_phase_diff_0, '1']
- [blocks_file_source_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_file_source_0_0, '0', band_pass_filter_0_0_0_0_0, '0']

metadata:
  file_format: 1
