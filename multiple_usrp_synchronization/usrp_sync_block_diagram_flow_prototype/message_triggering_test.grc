options:
  parameters:
    comment: |-
      In real case scenario remember to remove 
      throttle and subordinate the delay to the sample
       rate of the device (USRP, SDR dongle etc.) in order 
      to get reliable delays and timings (like the sample 
      rate is defining the clock of the flowchart in case of delay)
    generate_options: qt_gui
    id: run_message_triggering_test
    output_language: python
    title: Message triggering test
  states: {}

blocks:
- name: delay_clk_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: n_delay_secs
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: trigger_cmd
  id: variable_tag_object
  parameters:
    key: pmt.intern("TRIGGER")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.PMT_T
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: n_delay_secs*delay_clk_freq
    type: byte
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: delay_clk_freq
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    tags: '[trigger_cmd]'
    type: byte
    vector: (0,0)
  states: {}
- name: pdu_utils_tag_message_trigger_0_0
  id: pdu_utils_tag_message_trigger
  parameters:
    arm_key: pmt.PMT_NIL
    delay_time: '5'
    holdoff: '0'
    msg: sync_pymod.get_cmd_dict()
    samp_rate: samp_rate
    showport: 'True'
    start_time: '0.0'
    tpdu_mode: 'False'
    trig_key: pmt.intern("TRIGGER")
    type: b
  states: {}
- name: sync_pymod
  id: epy_module
  parameters:
    source_code: |
      import gnuradio
      import pmt

      def get_cmd_dict():
      	cmd = pmt.make_dict()
      	cmd = pmt.dict_add(cmd, pmt.intern("time"), pmt.from_long(10))
      	cmd = pmt.dict_add(cmd, pmt.intern("freq"), pmt.from_double(94.6e+6))
      	return cmd
  states: {}

connections:
- [blocks_delay_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', pdu_utils_tag_message_trigger_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_delay_0_0, '0']
- [pdu_utils_tag_message_trigger_0_0, msg, blocks_message_debug_0_0, print]

metadata:
  file_format: 1
