options:
  parameters:
    generate_options: qt_gui
    id: run_real_case_music_with_mag_eq
    output_language: python
    title: Real case MUSIC with magnitude equalization
  states: {}

blocks:
- name: calibrate_phase_offsets
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: qtgui_tab_widget_0@0:0,0,1,1
    label: Calibrate phase offsets?
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: '2.45e+9'
  states: {}
- name: equalize_amplitudes
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: qtgui_tab_widget_0@1:0,0,1,1
    label: Equalize amplitudes?
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: mav_length
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: music_output_rate
  id: variable
  parameters:
    value: int(samp_rate/(2048-512))
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: src_att
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '89'
    value: '35'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: calibrate_phase_offsets
    type: byte
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50e+3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '120e+3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_MUSIC_lin_array_0
  id: aoa_MUSIC_lin_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '1024'
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: '512'
    snapshot_size: '2048'
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '1'
    norm_spacing: '0.5'
  states: {}
- name: aoa_precise_moving_average_0
  id: aoa_precise_moving_average
  parameters:
    length: mav_length
    max_iter: mav_length
  states: {}
- name: aoa_precise_moving_average_0_0
  id: aoa_precise_moving_average
  parameters:
    length: mav_length
    max_iter: mav_length
  states: {}
- name: aoa_precise_moving_average_0_0_0
  id: aoa_precise_moving_average
  parameters:
    length: mav_length
    max_iter: mav_length
  states: {}
- name: aoa_rootMUSIC_linear_array_0
  id: aoa_rootMUSIC_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase
  parameters:
    dummy_param: ''
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 55e3
    low_cutoff_freq: 45e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 55e3
    low_cutoff_freq: 45e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate*1)
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(1e6)
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: calibrate_phase_offsets
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: calibrate_phase_offsets
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: equalize_amplitudes
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: equalize_amplitudes
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: src_att
    auto_filter: 'True'
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '2450000000'
    samplerate: '1000000'
    uri: 192.168.0.40
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@0:0,1,1,1
    max: '2'
    min: '-2'
    name: '"Arg corrector coeff"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@1:0,1,1,1
    max: '180'
    min: '0'
    name: '"Estimated AoA"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    color1: ("black", "white")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@1:2,0,1,1
    label1: Chan 1
    label2: Chan 2
    max: '4'
    min: '0'
    name: '"Magnitude levels before"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    color1: ("black", "white")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@1:2,1,1,1
    label1: Chan 1
    label2: Chan 2
    max: '4'
    min: '0'
    name: '"Magnitude levels after corr"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Calibration
    label1: MUSIC
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:1,0,1,1
    name: '"Signals before phase correction"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '-0.3'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:2,0,1,1
    name: '"Signals after phase correction"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '-0.3'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"MUSIC pspectrum"'
    size: '1024'
    srate: music_output_rate
    type: float
    update_time: '0.01'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:1,1,1,1
    name: '"Phase shift coeff"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2.0'
    ymin: '1.8'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1:1,0,1,2
    name: '"MUSIC Pspectrum"'
    update_time: '1'
    vlen: '1024'
    x_axis_label: '"Angle"'
    x_start: '0'
    x_step: 180/1024
    y_axis_label: '"Pspectrum"'
    ymax: '1'
    ymin: '-80'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0:2,1,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_frequency
    center_freq1: center_frequency
    clock_source0: internal
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_frequency
    center_freq1: center_frequency
    clock_source0: internal
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sample_and_hold_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_magphase_to_complex_0, '1']
- [analog_const_source_x_1, '0', blocks_magphase_to_complex_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_selector_0_0, '0']
- [aoa_MUSIC_lin_array_0, '0', blocks_vector_to_stream_0, '0']
- [aoa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_autocorrelate_0, '0', aoa_MUSIC_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_rootMUSIC_linear_array_0, '0']
- [aoa_calc_phase_diff_0, '0', aoa_precise_moving_average_0, '0']
- [aoa_precise_moving_average_0, '0', blocks_sample_and_hold_xx_0, '0']
- [aoa_precise_moving_average_0, '0', qtgui_time_sink_x_2, '0']
- [aoa_precise_moving_average_0_0, '0', blocks_max_xx_0, '0']
- [aoa_precise_moving_average_0_0_0, '0', blocks_max_xx_0, '1']
- [aoa_rootMUSIC_linear_array_0, '0', qtgui_number_sink_0_0, '0']
- [aoa_shift_phase_0, '0', blocks_complex_to_mag_1, '0']
- [aoa_shift_phase_0, '0', blocks_complex_to_real_0_2, '0']
- [aoa_shift_phase_0, '0', blocks_multiply_xx_0_0, '0']
- [aoa_shift_phase_0, '0', blocks_selector_1_0_0, '0']
- [band_pass_filter_0, '0', aoa_calc_phase_diff_0, '0']
- [band_pass_filter_0_0, '0', aoa_calc_phase_diff_0, '1']
- [band_pass_filter_0_0_0, '0', aoa_autocorrelate_0, '0']
- [band_pass_filter_0_0_0_0, '0', aoa_autocorrelate_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_number_sink_1, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_number_sink_1, '1']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_number_sink_1_1, '1']
- [blocks_complex_to_mag_0_1, '0', qtgui_number_sink_1_1, '0']
- [blocks_complex_to_mag_1, '0', aoa_precise_moving_average_0_0_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_divide_xx_0_0, '1']
- [blocks_complex_to_mag_1_0, '0', aoa_precise_moving_average_0_0, '0']
- [blocks_complex_to_mag_1_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_real_0_2, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_delay_0, '0', uhd_usrp_sink_0, '0']
- [blocks_delay_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_divide_xx_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_magphase_to_complex_0_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_magphase_to_complex_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_max_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_max_xx_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_mag_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_1_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_selector_1_0_0, '1']
- [blocks_null_source_0, '0', blocks_selector_0, '0']
- [blocks_null_source_0, '0', uhd_usrp_sink_0, '1']
- [blocks_null_source_0_0, '0', blocks_selector_0_0, '1']
- [blocks_sample_and_hold_xx_0, '0', aoa_shift_phase_0, '1']
- [blocks_sample_and_hold_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0, '0', blocks_delay_0, '0']
- [blocks_selector_0_0, '0', blocks_delay_0_0, '0']
- [blocks_selector_1_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_selector_1_0_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_1_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '1', aoa_shift_phase_0, '0']
- [uhd_usrp_source_0, '1', band_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_mag_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_real_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_waterfall_sink_x_0, '1']

metadata:
  file_format: 1
