options:
  parameters:
    generate_options: qt_gui
    id: run_corr_coeff_mav_test
    output_language: python
    title: Correction coefficient MAV test
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: '2.45e+9'
  states: {}
- name: chan_bandwidth
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 1+3j
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: 8+2j
    type: complex
  states: {}
- name: aoa_calc_phase_diff_0_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '1'
    norm_spacing: '0.5'
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_2_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e6)
    max_iter: int(2e6)
    scale: 1/1e6
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_2_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e6)
    max_iter: int(2e6)
    scale: 1/1e6
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_2_1_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e7)
    max_iter: int(2e7)
    scale: 1/1e7
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_2_1_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e7)
    max_iter: int(2e7)
    scale: 1/1e7
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_3_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e8)
    max_iter: int(2e8)
    scale: 1/1e8
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_3_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e8)
    max_iter: int(2e8)
    scale: 1/1e8
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-2'
    name: '"Phase corr coeffs"'
    nconnections: '8'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '3'
    min: '0.5'
    name: '"Magnitude corr coeffs"'
    nconnections: '8'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Phase shift MAV"'
    nconnections: '3'
    size: int(1e6)
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Mag corr MAV"'
    nconnections: '3'
    size: int(1e6)
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-2'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [aoa_calc_phase_diff_0_0, '0', blocks_moving_average_xx_0_0_2_0_0_0, '0']
- [aoa_calc_phase_diff_0_0, '0', blocks_moving_average_xx_0_0_2_1_0, '0']
- [aoa_calc_phase_diff_0_0, '0', blocks_moving_average_xx_0_0_3_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_complex_to_mag_0_1, '0', blocks_divide_xx_0_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_moving_average_xx_0_0_2_0_0_0_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_moving_average_xx_0_0_2_1_0_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_moving_average_xx_0_0_3_0_0, '0']
- [blocks_moving_average_xx_0_0_2_0_0_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_moving_average_xx_0_0_2_0_0_0_0, '0', qtgui_time_sink_x_3_0, '0']
- [blocks_moving_average_xx_0_0_2_1_0, '0', qtgui_time_sink_x_3, '1']
- [blocks_moving_average_xx_0_0_2_1_0_0, '0', qtgui_time_sink_x_3_0, '1']
- [blocks_moving_average_xx_0_0_3_0, '0', qtgui_time_sink_x_3, '2']
- [blocks_moving_average_xx_0_0_3_0_0, '0', qtgui_time_sink_x_3_0, '2']
- [blocks_throttle_0, '0', aoa_calc_phase_diff_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0_1, '0']
- [blocks_throttle_0_0, '0', aoa_calc_phase_diff_0_0, '1']
- [blocks_throttle_0_0, '0', blocks_complex_to_mag_0_0_0, '0']

metadata:
  file_format: 1
