options:
  parameters:
    generate_options: qt_gui
    id: run_precise_mav_test
    output_language: python
    title: 'Precise MAV accuracy test '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '5'
    type: float
  states: {}
- name: aoa_precise_moving_average_0
  id: aoa_precise_moving_average
  parameters:
    length: int(1e8)
    max_iter: int(1e8)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/gr-mav.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/my_precise_mav.bin
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1e8)
    max_iter: int(1e8)
    scale: 1/int(1e8)
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: int(1e5)
    taps: '1'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: int(1e5)
    taps: '1'
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [aoa_precise_moving_average_0, '0', fir_filter_xxx_0, '0']
- [blocks_moving_average_xx_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', aoa_precise_moving_average_0, '0']
- [blocks_throttle_0, '0', blocks_moving_average_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
