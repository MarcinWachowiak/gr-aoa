options:
  parameters:
    generate_options: qt_gui
    id: run_music_algo_simulation_4rx_2tx_no_phase_jitter
    output_language: python
    title: 'MUSIC simulation 4 RX, 2 SRC, no phase jitter '
  states: {}

blocks:
- name: NormSpacing
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: NumArrayElements
  id: variable
  parameters:
    value: '4'
  states: {}
- name: NumTargets
  id: variable
  parameters:
    value: '2'
  states: {}
- name: amv0
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))
  states: {}
- name: amv1
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(NormSpacing, numpy.arange(NumArrayElements/2, -NumArrayElements/2, -1) if (NumArrayElements%2==1) else numpy.arange(NumArrayElements/2-0.5, -NumArrayElements/2-0.5, -1))
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0, amv1]).transpose()
  states: {}
- name: mag_diff
  id: variable_qtgui_range
  parameters:
    label: Magnitude difference
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.5'
    step: '0.01'
    stop: '1.5'
    value: '1'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: theta0
  id: variable
  parameters:
    value: numpy.pi*theta0_deg/180
  states: {}
- name: theta0_deg
  id: variable_qtgui_range
  parameters:
    label: AoA 1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '40'
  states: {}
- name: theta1
  id: variable
  parameters:
    value: numpy.pi*theta1_deg/180
  states: {}
- name: theta1_deg
  id: variable_qtgui_range
  parameters:
    label: AoA 2
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '120'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '972353'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '3135154'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10E+3'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '30E+3'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    norm_spacing: NormSpacing
    num_inputs: NumArrayElements
    num_targets: NumTargets
    pspectrum_len: '1024'
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '4'
    overlap_size: '512'
    snapshot_size: '1024'
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: NormSpacing
    num_inputs: NumArrayElements
    num_targets: NumTargets
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mag_diff
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"MUSIC Pspectrum"'
    update_time: '0.1'
    vlen: '1024'
    x_axis_label: '"Angle"'
    x_start: '0'
    x_step: 180/1024
    y_axis_label: '"Pspectrum"'
    ymin: '-80'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_root_music_linear_array_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_deinterleave_0, '0', qtgui_number_sink_0, '0']
- [blocks_deinterleave_0, '1', qtgui_number_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', aoa_autocorrelate_0, '0']
- [blocks_multiply_matrix_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_matrix_xx_0, '1', aoa_autocorrelate_0, '1']
- [blocks_multiply_matrix_xx_0, '2', aoa_autocorrelate_0, '2']
- [blocks_multiply_matrix_xx_0, '3', aoa_autocorrelate_0, '3']
- [blocks_throttle_0_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
