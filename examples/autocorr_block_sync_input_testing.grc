options:
  parameters:
    generate_options: qt_gui
    id: run_autocorr_block_sync_input_testing
    output_language: python
    title: Autocorrelation block sync input testing
  states: {}

blocks:
- name: imag
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-2'
    step: '0.05'
    stop: '2'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.1'
  states: {}
- name: overlap_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: real
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1e+6'
  states: {}
- name: snap_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '6465456'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '10902933'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100E+3'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_autocorrelate_0_0_0_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: '0'
    snapshot_size: snap_size-overlap_size
  states: {}
- name: aoa_autocorrelate_0_0_0_0_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: overlap_size
    snapshot_size: snap_size
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_root_music_linear_array_0_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase
  parameters:
    dummy_param: ''
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: '0.1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    name: '"AoA no overlap"'
    size: int(1e4)
    srate: sample_rate/(snap_size-overlap_size)
    type: float
    ymax: '91'
    ymin: '89'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    name: '"With overlap"'
    size: int(1e4)
    srate: sample_rate/(snap_size-overlap_size)
    type: float
    ymax: '91'
    ymin: '89'
  states: {}

connections:
- [analog_const_source_x_0, '0', aoa_shift_phase_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [aoa_autocorrelate_0_0_0_0, '0', aoa_root_music_linear_array_0_0, '0']
- [aoa_autocorrelate_0_0_0_0_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_time_sink_x_0_1, '0']
- [aoa_root_music_linear_array_0_0, '0', qtgui_time_sink_x_0, '0']
- [aoa_shift_phase_0, '0', aoa_autocorrelate_0_0_0_0, '1']
- [blocks_add_xx_0, '0', aoa_autocorrelate_0_0_0_0, '0']
- [blocks_add_xx_0, '0', aoa_autocorrelate_0_0_0_0_0, '0']
- [blocks_add_xx_0_0, '0', aoa_autocorrelate_0_0_0_0_0, '1']
- [blocks_add_xx_0_0, '0', aoa_shift_phase_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle_0, '0', channels_phase_noise_gen_0, '0']
- [channels_phase_noise_gen_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
