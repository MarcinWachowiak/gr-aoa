options:
  parameters:
    generate_options: qt_gui
    id: run_music_algo_simulation_2rx_magnitude_difference_effects
    output_language: python
    title: MUSIC simulation, 2RX, 1 SRC manual mag difference eval
  states: {}

blocks:
- name: imag
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-2'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: real
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '32e+3'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10E+3'
    offset: '0'
    phase: '0'
    samp_rate: '320E+3'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '1024'
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: '512'
    snapshot_size: '1024'
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: real
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: '0.1'
  states: {}
- name: phase
  id: blocks_add_const_vxx
  parameters:
    const: imag
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"MUSIC Pspectrum"'
    update_time: '0.1'
    vlen: '1024'
    x_axis_label: '"Angle"'
    x_start: '0'
    x_step: 180/1024
    y_axis_label: '"Pspectrum"'
    ymin: '-80'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_magphase_0, '1', phase, '0']
- [blocks_magphase_to_complex_0, '0', aoa_autocorrelate_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_throttle_0_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_throttle_0_0, '0', channels_phase_noise_gen_0, '0']
- [channels_phase_noise_gen_0, '0', aoa_autocorrelate_0, '0']
- [phase, '0', blocks_magphase_to_complex_0, '1']

metadata:
  file_format: 1
