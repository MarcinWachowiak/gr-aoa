options:
  parameters:
    generate_options: qt_gui
    id: run_real_case_music_test
    output_language: python
    title: Real case MUSIC test
  states: {}

blocks:
- name: calibrate_phase_offsets
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Calibrate phase offsets?
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: int(2.4399e+9)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: source_power
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '89'
    value: '30'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: calibrate_phase_offsets
    type: byte
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '115e+3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '1024'
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: '512'
    snapshot_size: '2048'
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '1'
    norm_spacing: '0.5'
  states: {}
- name: aoa_precise_moving_average_0
  id: aoa_precise_moving_average
  parameters:
    length: int(1e5)
    max_iter: int(1e5)
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase
  parameters:
    dummy_param: ''
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_2_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: calibrate_phase_offsets
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: source_power
    auto_filter: 'True'
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: center_frequency
    samplerate: '1000000'
    uri: 192.168.0.40
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0:0,1,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@0
    max: '3.2'
    min: '-3.2'
    name: '"Arg corrector coeff"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@1
    max: '180'
    min: '0'
    name: '"Estimated AoA"'
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Calibration
    label1: MUSIC
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:1,0,1,1
    name: '"After"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '-0.3'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:0,0,1,1
    name: '"Before"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '-0.3'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    name: '"MUSIC Pspectrum"'
    update_time: '0.01'
    vlen: '1024'
    x_axis_label: '"Angle"'
    x_start: '0'
    x_step: 180/1024
    y_axis_label: '"Pspectrum"'
    ymax: '1'
    ymin: '-20'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0:1,1,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_frequency
    center_freq1: center_frequency
    clock_source0: internal
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sample_and_hold_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_selector_0_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_calc_phase_diff_0, '0', aoa_precise_moving_average_0, '0']
- [aoa_precise_moving_average_0, '0', blocks_sample_and_hold_xx_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0_0, '0']
- [aoa_shift_phase_0, '0', aoa_autocorrelate_0, '1']
- [aoa_shift_phase_0, '0', blocks_complex_to_real_0_2, '0']
- [band_pass_filter_0_0_0_0, '0', aoa_autocorrelate_0, '0']
- [band_pass_filter_0_0_0_0, '0', aoa_calc_phase_diff_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_real_0_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', aoa_calc_phase_diff_0, '1']
- [band_pass_filter_0_0_0_0_0, '0', aoa_shift_phase_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', blocks_complex_to_real_0_2_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [band_pass_filter_0_0_0_0_0, '0', qtgui_waterfall_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_real_0_0_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_real_0_2, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_complex_to_real_0_2_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_null_source_0_0, '0', blocks_selector_0_0, '1']
- [blocks_sample_and_hold_xx_0, '0', aoa_shift_phase_0, '1']
- [blocks_sample_and_hold_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0_0, '0', iio_pluto_sink_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0_0_0_0, '0']
- [uhd_usrp_source_0, '1', band_pass_filter_0_0_0_0_0, '0']

metadata:
  file_format: 1
