options:
  parameters:
    generate_options: qt_gui
    id: run_head_block_with_rst_msg_test
    output_language: python
    title: Head block with reset message test
  states: {}

blocks:
- name: reset_head_block
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: turn_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_head_w_rst_0
  id: aoa_head_w_rst
  parameters:
    dump_buff: 'True'
    num_items: int(1e5)
    type: float
    vlen: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: turn_on
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [aoa_head_w_rst_0, '0', qtgui_time_sink_x_1, '0']
- [aoa_head_w_rst_0, status, qtgui_edit_box_msg_0, val]
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', aoa_head_w_rst_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
