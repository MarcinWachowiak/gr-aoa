options:
  parameters:
    generate_options: qt_gui
    id: run_usrp_2xRX_continiuous_ampl_phase_correction_observe
    output_language: python
    title: USRP B210 phase and amplitude correction coefficient observe
  states: {}

blocks:
- name: ampl_var
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: '2401000000'
  states: {}
- name: chan_bandwidth
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '200000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl_var
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2000000'
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '2000000'
    type: complex
  states: {}
- name: blocks_skiphead_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: '1000000'
    type: complex
  states: {}
- name: blocks_skiphead_0_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: '1000000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: Signal
    label2: Conjugate of corrected signals
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: chan_bandwidth
    fc: '0'
    fftsize: 1024*4
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Real
    label2: Imag
    name: '"Coeff"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Reference
    label2: Unmodified
    label3: Corrected
    name: '"Unmodified"'
    nconnections: '3'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Reference
    label2: Sec corrected
    name: '"Corrected in time"'
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Real coeff in time"'
    size: '102400'
    srate: '10'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Imag coeff in time"'
    size: '102400'
    srate: '10'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Mag
    label2: Phase
    name: '"Before correction"'
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Mag
    label2: Phase
    name: '"after correction"'
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: chan_bandwidth
    bw1: chan_bandwidth
    center_freq0: center_frequency
    center_freq1: center_frequency
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: chan_bandwidth
    bw1: chan_bandwidth
    center_freq0: center_frequency
    center_freq1: center_frequency
    clock_rate: '0.0'
    clock_source0: internal
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: '"serial=3113F3B"'
    dev_args: '"master_clock_rate=16e6,num_recv_frames=1024"'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    minoutbuf: int(10e6)
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_number_sink_0_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_2, '1']
- [blocks_complex_to_magphase_0_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_3, '1']
- [blocks_complex_to_magphase_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_magphase_0_0_0, '1', qtgui_time_sink_x_1_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_real_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_real_2, '0', qtgui_number_sink_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_real_0_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_real_1, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_divide_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_magphase_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_real_2, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_null_source_1, '0', uhd_usrp_sink_0, '1']
- [blocks_skiphead_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_skiphead_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_skiphead_0, '0', blocks_multiply_xx_0, '1']
- [blocks_skiphead_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_skiphead_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_skiphead_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_skiphead_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_skiphead_0_0_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [blocks_skiphead_0_0_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [uhd_usrp_source_0, '0', blocks_skiphead_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_skiphead_0, '0']
- [uhd_usrp_source_0, '1', blocks_skiphead_0_0_0_0, '0']

metadata:
  file_format: 1
