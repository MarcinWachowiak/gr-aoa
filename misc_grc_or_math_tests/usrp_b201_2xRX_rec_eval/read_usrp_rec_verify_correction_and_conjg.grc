options:
  parameters:
    generate_options: qt_gui
    id: run_read_usrp_rec_verify_correction_and_conjg
    output_language: python
    title: Read usrp recorded files and verify phase correction and conjg
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/marcin/GNU-Radio-USRP-AoA/2xRX_b210_splitter_recieve_no_align/ch1_symmetrical_1.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/marcin/GNU-Radio-USRP-AoA/2xRX_b210_splitter_recieve_no_align/ch2_symmetrical_1.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.6675640911326157-0.7445523381403653j
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '80000'
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '80000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: Conjugate of corrected signals
    label2: Signal
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Reference
    label2: Unmodified
    label3: Corrected
    name: '"Signals in time"'
    nconnections: '3'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Mag
    label2: Phase
    name: '"Before correction"'
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Mag
    label2: Phase
    name: '"after correction"'
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '1'
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_2, '1']
- [blocks_complex_to_magphase_0_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_3, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_file_source_0, '0', blocks_skiphead_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_skiphead_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_skiphead_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_skiphead_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_skiphead_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_skiphead_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_skiphead_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_skiphead_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_skiphead_0_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
