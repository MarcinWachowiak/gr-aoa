options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: run_usrp_b201_2xRX_save_sampl_to_file
    output_language: python
    run_options: run
    title: USRP B210 2RX save IQ data to file
  states: {}

blocks:
- name: rec_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/sync_testing/ch1_symmetrical_x.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/marcin/Desktop/sync_testing/ch2_symmetrical_x.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*rec_time)
    type: complex
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*rec_time)
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: center_frequency
  id: parameter
  parameters:
    label: center_frequency
    type: eng_float
    value: 2.4e9
  states: {}
- name: chan_bandwidth
  id: parameter
  parameters:
    label: chan_bandwidth
    value: 1e6
  states: {}
- name: gain_rx_1
  id: parameter
  parameters:
    label: gain_rx_1
    type: eng_float
    value: '20'
  states: {}
- name: gain_rx_2
  id: parameter
  parameters:
    label: gain_rx_2
    type: eng_float
    value: '20'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Change device adresses
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: 1e6
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: chan_bandwidth
    bw1: chan_bandwidth
    center_freq0: center_frequency
    center_freq1: center_frequency
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: chan_bandwidth
    bw1: chan_bandwidth
    center_freq0: center_frequency
    center_freq1: center_frequency
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: ''
    dev_args: '"master_clock_rate=16e6,num_recv_frames=1024"'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    minoutbuf: int(10e6)
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_null_source_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '1', blocks_head_0_0_0, '0']

metadata:
  file_format: 1
