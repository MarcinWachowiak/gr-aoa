options:
  parameters:
    comment: |-
      To reset the head block use proper callback:

          def set_trigger_measurment(self, trigger_measurment):
              self.trigger_measurment = trigger_measurment
              self._trigger_measurment_callback(self.trigger_measurment)
              
              if trigger_measurment == True:
                  self.blocks_file_sink_0.open(testbench_setup_pymodule.get_meas_path(self.distance, self.rx_gain, self.src_att, self.physical_aoa))
                  self.aoa_head_w_rst_0.reset(True)
                  self.blocks_selector_1.set_output_index(self.trigger_measurment)
    generate_options: qt_gui
    id: resettable_head_block
    output_language: python
    title: Resettable head block test
  states: {}

blocks:
- name: distance
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '10'
    value: '2'
  states: {}
- name: physical_aoa
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '60'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e3)
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: int(1E+6)
  states: {}
- name: src_att
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: trigger_measurment
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '89'
    value: '35'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: physical_aoa
    type: float
  states: {}
- name: aoa_head_w_rst_0
  id: aoa_head_w_rst
  parameters:
    dump_buff: 'True'
    num_items: int(1e6)
    type: float
    vlen: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-90'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/marcin/GNU-Radio-USRP-AoA/misc_grc_or_math_tests/initial_empty_sample_file.bin
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: trigger_measurment
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: testbench_setup_pymodule
  id: epy_module
  parameters:
    source_code: |
      import os 

      def get_meas_path(distance, rx_gain, src_att, physical_aoa):
              glob_path = os.getcwd()
              meas_dir = "%s/meas_dist_%dm_rx_%ddB_src_att_%ddB" %(glob_path, distance, rx_gain, src_att)

              try:
                  os.mkdir(meas_dir)
              except OSError:
                  print ("Creation of the directory %s failed" % meas_dir)
              else:
                  print ("Successfully created the directory %s " % meas_dir)

              meas_path = "%s/angle_%d_err.bin" %(meas_dir,physical_aoa)
              print(meas_path)
              return meas_path
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [aoa_head_w_rst_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_0, '0']
- [blocks_selector_1, '1', aoa_head_w_rst_0, '0']
- [blocks_throttle_0, '0', blocks_selector_1, '0']
- [blocks_throttle_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
